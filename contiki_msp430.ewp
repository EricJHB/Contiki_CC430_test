# IAR project contiki_msp430.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsff.h
  General.OGChipSelectMenu: CC430F5137 CC430F5137
  General.GStackSize2: 500
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: core\; core\dev\; core\lib\; core\sys\; cpu\msp430\; cpu\msp430\dev\; platform\MSP430-169LCD\; platform\MSP430-169LCD\dev\; platform\MSP430-169LCD\loader\; platform\MSP430-169LCD\apps\; platform\MSP430-169LCD\apps\shell\; platform\MSP430-169LCD\apps\serial-shell\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnkcc430f5137.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group apps
    platform/MSP430-169LCD/apps/: blink.c burn-nodeid.c fader.c shell_blink.c
  group apps/serial-shell
    platform/MSP430-169LCD/apps/serial-shell/: cc430_shell.c serial-shell.c
  group apps/shell
    platform/MSP430-169LCD/apps/shell/: shell.c shell.h
  group core
    core/: contiki-lib.h contiki-net.h contiki-version.h contiki.h
  group core/cfs
    core/cfs/: cfs-coffee.c cfs-coffee.h cfs.h
  group core/dev
    core/dev/: battery-sensor.h button-sensor.h eeprom.h leds.c leds.h nullradio.c nullradio.h radio-sensor.h radio.h rom.h serial-line.c serial-line.h spi.h watchdog.h xmem.h
  group core/lib
    core/lib/: assert.c assert.h checkpoint.c checkpoint.h crc16.c crc16.h gcr.c gcr.h ifft.c ifft.h libconio.c libconio.h list.c list.h me.c me.h me_tabs.c me_tabs.h memb.c memb.h mmem.c mmem.h petsciiconv.c petsciiconv.h random.c random.h ringbuf.c ringbuf.h sensors.c sensors.h
  group core/net
    core/net/: linkaddr.c
  group core/sys
    core/sys/: arg.c arg.h autostart.c autostart.h cc.h clock.h ctimer.c ctimer.h dsc.h energest.c energest.h etimer.c etimer.h lc-addrlabels.h lc-switch.h lc.h loader.h log.h mt.c mt.h process.c process.h procinit.c procinit.h pt-sem.h pt.h rtimer.c rtimer.h stimer.c stimer.h subprocess.h timer.c timer.h
  group cpu/msp430
    cpu/msp430/: button.c clock.c leds-arch.c lpm.c msp430.c msp430def.h mtarch.c mtarch.h rom.c rtimer-arch.c rtimer-arch.h spi.c uip-ipchksum.c watchdog.c
  group cpu/msp430/dev
    cpu/msp430/dev/: button.h flash.h hwconf.h lpm.h uart0.h uart0x.c
  group platform
    platform/MSP430-169LCD/: cfs-coffee-arch.h contiki-conf.h contiki-sky-main.c contiki-sky-platform.c node-id.c node-id.h platform-conf.h
  group platform/CC430xx_dk
    platform/MSP430-169LCD/: cfs-coffee-arch.c
  group platform/CC430xx_dk/dev
    platform/MSP430-169LCD/dev/: battery-sensor.c i2c.c i2c.h radio-sensor.c sht11-arch.h temperature-sensor.h
  group platform/CC430xx_dk/HAL
    platform/MSP430-169LCD/HAL/: hal_pmm.c INFlashWR.c RF1A.c
